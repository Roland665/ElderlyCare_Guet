# Keil uVision project object.uvprojx, settings and files
target Terminal (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM;..\components;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c FreeRTOSConfig.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/timer/: timer.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_exti.c
  group README
    ../: README.TXT
  group FreeRTOS
    ../FreeRTOS/port/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group components
    ../components/KEY/: key.c
    ../components/LED/: led.c
    ../components/TEA/: tea.c
    ../components/Zigbee/: Zigbee.c
    ../components/DHT11/: DHT11.c
